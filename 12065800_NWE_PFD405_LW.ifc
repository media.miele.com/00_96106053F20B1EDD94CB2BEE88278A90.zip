Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-10-19T11:20:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 11:20:29 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\7dc9f386-7a25-4c8a-ad6a-3839b89f9acf\136a500c-f32d-459e-9c2d-5ace8e0b89cd\ifc * Database version: 5507 * Database creation date: Wed Oct 19 11:20:28 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 11:20:29 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 11:20:29 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12065800_NWE_PFD405_LW:61040501_NWE_12065800_PFD405_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 61040501_NWE_12065800_PFD405_LW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 61040501_NWE_12065800_PFD405_LW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
